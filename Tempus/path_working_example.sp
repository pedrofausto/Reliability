// Generated by Cadence Encounter(R) RTL Compiler v12.10-p006_1

simulator lang=spectre
global 0 vdd!

include "model/pmos.scs"
include "model/nmos.scs"

V0 (vdd! 0) vsource dc=1.1 type=dc

// Library name: AgingBib
// Cell name: NAND2_A
// View name: schematic
subckt NAND2_A Z A B vdd gnd
    TNA (Z A net20 gnd) nch w=1.0u l=45n
    TNB (net20 B gnd gnd) nch w=1.0u l=45n
    TPA (Z A vdd vdd) pch w=2.0u l=45n
    TPB (Z B vdd vdd) pch w=2.0u l=45n
ends NAND2_A
// End of subcircuit definition.

// Library name: AgingBib
// Cell name: OR2_B
// View name: schematic
subckt OR2_B Z A B vdd gnd
    TNZ (Z net28 gnd gnd) nch w=1.0u l=45n
    TNB (net28 B gnd gnd) nch w=1.0u l=45n
    TNA (net28 A gnd gnd) nch w=1.0u l=45n
    TPZ (Z net28 vdd vdd) pch w=2.0u l=45n
    TPA (net28 A net34 vdd) pch w=2.0u l=45n
    TPB (net34 B vdd vdd) pch w=2.0u l=45n
ends OR2_B
// End of subcircuit definition.

// Library name: AgingBib
// Cell name: AND2_B
// View name: schematic
subckt AND2_B Z A B vdd gnd
    TNA (net29 A net34 gnd) nch w=1.0u l=45n
    TNB (net34 B gnd gnd) nch w=1.0u l=45n
    TNZ (Z net29 gnd gnd) nch w=1.0u l=45n
    TPB (net29 B vdd vdd) pch w=2.0u l=45n
    TPA (net29 A vdd vdd) pch w=2.0u l=45n
    TPZ (Z net29 vdd vdd) pch w=2.0u l=45n
ends AND2_B
// End of subcircuit definition.

// Library name: AgingBib
// Cell name: INVERT_I
// View name: schematic
subckt INVERT_I Z A vdd gnd
    TNAM2 (Z A gnd gnd) nch w=1.0u l=45n
    TNAM1 (Z A gnd gnd) nch w=1.0u l=45n
    TPAM1 (Z A vdd vdd) pch w=2.0u l=45n
    TPAM2 (Z A vdd vdd) pch w=2.0u l=45n
ends INVERT_I
// End of subcircuit definition.

// Library name: AgingBib
// Cell name: NOR2_A
// View name: schematic
subckt NOR2_A Z A B vdd gnd
    TNA (Z A gnd gnd) nch w=1.0u l=45n
    TNB (Z B gnd gnd) nch w=1.0u l=45n
    TPA (Z A net18 vdd) pch w=2.0u l=45n
    TPB (net18 B vdd vdd) pch w=2.0u l=45n
ends NOR2_A
// End of subcircuit definition.

simulatorOptions options reltol=1e-3 vabstol=1e-6 iabstol=1e-12 temp=0 \
    tnom=70 scalem=1.0 scale=1.0 gmin=1e-12 rforce=0.1 maxnotes=5 maxwarns=5 \
    digits=5 cols=80 pivrel=1e-3 ckptclock=1800 rawfmt=psfxl method=trap \
    sensfile="../psf/sens.output"
tran tran stop=6ns write="spectre.ic" writefinal="spectre.fc" \
    annotate=status maxiters=5
finalTimeOP info what=oppoint where=rawfile
modelParameter info what=models where=rawfile
element info what=inst where=rawfile
outputParameter info what=output where=rawfile
saveOptions options save=lvlpub nestlvl=1

simulator lang=spice

**************************************
*Command:	create_spice_deck
**************************************

*--------------------
*Stage Instances
*--------------------
XStage1 X_51gat U2828/A Stage1
XStage2 U2828/A U2828/Z U2779/A Stage2
XStage3 U2779/A U2779/Z U2826/B Stage3
XStage4 U2826/B U2826/Z U2780/A Stage4
XStage5 U2780/A U2780/Z U2939/B Stage5
XStage6 U2939/B U2939/Z U2834/B Stage6
XStage7 U2834/B U2834/Z U2790/A Stage7
XStage8 U2790/A U2790/Z U2820/B Stage8
XStage9 U2820/B U2820/Z U2922/A Stage9
XStage10 U2922/A U2922/Z U2792/B Stage10
XStage11 U2792/B U2792/Z U2951/A Stage11
XStage12 U2951/A U2951/Z U2952/A Stage12
XStage13 U2952/A U2952/Z U2795/B Stage13
XStage14 U2795/B U2795/Z U2955/B Stage14
XStage15 U2955/B U2955/Z U2956/B Stage15
XStage16 U2956/B U2956/Z U2798/B Stage16
XStage17 U2798/B U2798/Z U2959/B Stage17
XStage18 U2959/B U2959/Z U2960/B Stage18
XStage19 U2960/B U2960/Z U2801/B Stage19
XStage20 U2801/B U2801/Z U2963/B Stage20
XStage21 U2963/B U2963/Z U2964/B Stage21
XStage22 U2964/B U2964/Z U2805/B Stage22
XStage23 U2805/B U2805/Z U2966/A Stage23
XStage24 U2966/A U2966/Z U2979/A Stage24
XStage25 U2979/A U2979/Z U2980/B Stage25
XStage26 U2980/B U2980/Z U2811/B Stage26
XStage27 U2811/B U2811/Z U2995/B Stage27
XStage28 U2995/B U2995/Z U2996/A Stage28
XStage29 U2996/A U2996/Z U2815/B Stage29
XStage30 U2815/B U2815/Z U2998/A Stage30
XStage31 U2998/A U2998/Z U2999/B Stage31
XStage32 U2999/B U2999/Z U3000/B Stage32
XStage33 U3000/B U3000/Z U3086/B Stage33
XStage34 U3086/B U3086/Z U3001/B Stage34
XStage35 U3001/B U3001/Z U3006/B Stage35
XStage36 U3006/B U3006/Z U2858/B Stage36
XStage37 U2858/B U2858/Z U2764/A Stage37
XStage38 U2764/A U2764/Z X_878gat Stage38
*---------------------

*--------------------
*Input Event
*--------------------

*Input event offset(1e-09)
*full transition time 5.31888e-12
V1 X_51gat 0 PWL(
+ 9.99999971718e-10        0
+ 1.00019997167e-09        0.0324
+ 1.00035988954e-09        0.081
+ 1.00049996911e-09        0.162
+ 1.00080524673e-09        0.324
+ 1.00114954087e-09        0.486
+ 1.00154064577e-09        0.648
+ 1.00198757451e-09        0.81
+ 1.00249997323e-09        0.972
+ 1.00531884857e-09        1.1
+)

*---------------------

*--------------------
*Stage subckts
*--------------------
.SUBCKT Stage1 X_51gat U2828/A

*side receiver Inst(U2978)
XU2978 U2978/Z U2978/A U2978/B U2978/VDD! U2978/GND!  NAND2_A
V1 U2978/VDD! 0 1.1
V2 U2978/GND! 0 0
V3 U2978/A 0 1.1

*Net victim vic(X_51gat)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic X_51gat 0.0001
R2 vic U2978/B 0.0001
R3 vic U2828/A 0.0001

*Net connected to side receiver's o/p rcv1(n_308)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv1 U2978/Z 0.0001
R5 rcv1 U2850/A 0.0001
C1 U2850/A 0 2.597e-15
.ENDS

.SUBCKT Stage2 U2828/A U2828/Z U2779/A

*driver Inst(U2828)
XU2828 U2828/Z U2828/A U2828/B U2828/VDD! U2828/GND!  AND2_B
V1 U2828/VDD! 0 1.1
V2 U2828/GND! 0 0
V3 U2828/B 0 1.1

*side receiver Inst(U2829)
XU2829 U2829/Z U2829/A U2829/B U2829/VDD! U2829/GND!  AND2_B
V4 U2829/VDD! 0 1.1
V5 U2829/GND! 0 0
V6 U2829/B 0 1.1

*Net victim vic(n_417)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2828/Z 0.0001
R2 vic U2829/A 0.0001
R3 vic U2779/A 0.0001

*Net connected to side receiver's o/p rcv1(n_333)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv1 U2829/Z 0.0001
R5 rcv1 U2929/B 0.0001
C1 U2929/B 0 2.431e-15
.ENDS

.SUBCKT Stage3 U2779/A U2779/Z U2826/B

*driver Inst(U2779)
XU2779 U2779/Z U2779/A U2779/B U2779/VDD! U2779/GND!  AND2_B
V1 U2779/VDD! 0 1.1
V2 U2779/GND! 0 0
V3 U2779/B 0 1.1

*side receiver Inst(U2940)
XU2940 U2940/Z U2940/A U2940/B U2940/VDD! U2940/GND!  NAND2_A
V4 U2940/VDD! 0 1.1
V5 U2940/GND! 0 0
V6 U2940/A 0 1.1

*side receiver Inst(U2831)
XU2831 U2831/Z U2831/A U2831/B U2831/VDD! U2831/GND!  NAND2_A
V7 U2831/VDD! 0 1.1
V8 U2831/GND! 0 0
V9 U2831/B 0 1.1

*side receiver Inst(U2781)
XU2781 U2781/Z U2781/A U2781/B U2781/VDD! U2781/GND!  AND2_B
V10 U2781/VDD! 0 1.1
V11 U2781/GND! 0 0
V12 U2781/A 0 1.1

*Net victim vic(X_447gat)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2779/Z 0.0001
R2 vic X_447gat 0.0001
R3 vic U2940/B 0.0001
R4 vic U2831/A 0.0001
R5 vic U2826/B 0.0001
R6 vic U2781/B 0.0001
C1 X_447gat 0 1e-17

*Net connected to side receiver's o/p rcv1(n_171)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv1 U2940/Z 0.0001
R8 rcv1 U2941/B 0.0001
C2 U2941/B 0 2.431e-15

*Net connected to side receiver's o/p rcv2(n_331)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R9 rcv2 U2831/Z 0.0001
R10 rcv2 U2930/A 0.0001
C3 U2930/A 0 2.711e-15

*Net connected to side receiver's o/p rcv4(n_413)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R11 rcv4 U2781/Z 0.0001
R12 rcv4 U2993/B 0.0001
R13 rcv4 U2977/B 0.0001
R14 rcv4 U2935/A 0.0001
R15 rcv4 U2934/B 0.0001
C4 U2993/B 0 2.431e-15
C5 U2977/B 0 2.431e-15
C6 U2935/A 0 2.295e-15
C7 U2934/B 0 2.431e-15
.ENDS

.SUBCKT Stage4 U2826/B U2826/Z U2780/A

*driver Inst(U2826)
XU2826 U2826/Z U2826/A U2826/B U2826/VDD! U2826/GND!  AND2_B
V1 U2826/VDD! 0 1.1
V2 U2826/GND! 0 0
V3 U2826/A 0 1.1

*Net victim vic(n_415)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2826/Z 0.0001
R2 vic U2780/A 0.0001
.ENDS

.SUBCKT Stage5 U2780/A U2780/Z U2939/B

*driver Inst(U2780)
XU2780 U2780/Z U2780/A U2780/B U2780/VDD! U2780/GND!  AND2_B
V1 U2780/VDD! 0 1.1
V2 U2780/GND! 0 0
V3 U2780/B 0 1.1

*side receiver Inst(U2932)
XU2932 U2932/Z U2932/A U2932/B U2932/VDD! U2932/GND!  NAND2_A
V4 U2932/VDD! 0 1.1
V5 U2932/GND! 0 0
V6 U2932/A 0 1.1

*Net victim vic(n_416)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2780/Z 0.0001
R2 vic U2939/B 0.0001
R3 vic U2932/B 0.0001

*Net connected to side receiver's o/p rcv2(n_320)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv2 U2932/Z 0.0001
R5 rcv2 U2854/B 0.0001
R6 rcv2 U2849/B 0.0001
R7 rcv2 U2840/A 0.0001
R8 rcv2 U2839/B 0.0001
C1 U2854/B 0 2.636e-15
C2 U2849/B 0 2.636e-15
C3 U2840/A 0 2.597e-15
C4 U2839/B 0 2.636e-15
.ENDS

.SUBCKT Stage6 U2939/B U2939/Z U2834/B

*driver Inst(U2939)
XU2939 U2939/Z U2939/A U2939/B U2939/VDD! U2939/GND!  NAND2_A
V1 U2939/VDD! 0 1.1
V2 U2939/GND! 0 0
V3 U2939/A 0 1.1

*side receiver Inst(U2836)
XU2836 U2836/Z U2836/A U2836/B U2836/VDD! U2836/GND!  AND2_B
V4 U2836/VDD! 0 1.1
V5 U2836/GND! 0 0
V6 U2836/B 0 1.1

*side receiver Inst(U2835)
XU2835 U2835/Z U2835/A U2835/B U2835/VDD! U2835/GND!  AND2_B
V7 U2835/VDD! 0 1.1
V8 U2835/GND! 0 0
V9 U2835/A 0 1.1

*side receiver Inst(U2833)
XU2833 U2833/Z U2833/A U2833/B U2833/VDD! U2833/GND!  AND2_B
V10 U2833/VDD! 0 1.1
V11 U2833/GND! 0 0
V12 U2833/A 0 1.1

*Net victim vic(n_327)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2939/Z 0.0001
R2 vic U2836/A 0.0001
R3 vic U2835/B 0.0001
R4 vic U2834/B 0.0001
R5 vic U2833/B 0.0001

*Net connected to side receiver's o/p rcv1(n_385)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R6 rcv1 U2836/Z 0.0001
R7 rcv1 U2797/A 0.0001
C1 U2797/A 0 2.597e-15

*Net connected to side receiver's o/p rcv2(n_393)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R8 rcv2 U2835/Z 0.0001
R9 rcv2 U2793/A 0.0001
C2 U2793/A 0 2.597e-15

*Net connected to side receiver's o/p rcv4(n_399)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R10 rcv4 U2833/Z 0.0001
R11 rcv4 U2791/A 0.0001
C3 U2791/A 0 2.597e-15
.ENDS

.SUBCKT Stage7 U2834/B U2834/Z U2790/A

*driver Inst(U2834)
XU2834 U2834/Z U2834/A U2834/B U2834/VDD! U2834/GND!  AND2_B
V1 U2834/VDD! 0 1.1
V2 U2834/GND! 0 0
V3 U2834/A 0 1.1

*Net victim vic(n_402)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2834/Z 0.0001
R2 vic U2790/A 0.0001
.ENDS

.SUBCKT Stage8 U2790/A U2790/Z U2820/B

*driver Inst(U2790)
XU2790 U2790/Z U2790/A U2790/B U2790/VDD! U2790/GND!  AND2_B
V1 U2790/VDD! 0 1.1
V2 U2790/GND! 0 0
V3 U2790/B 0 1.1

*side receiver Inst(U3055)
XU3055 U3055/Z U3055/A U3055/B U3055/VDD! U3055/GND!  OR2_B
V4 U3055/VDD! 0 1.1
V5 U3055/GND! 0 0
V6 U3055/A 0 0

*side receiver Inst(U2913)
XU2913 U2913/Z U2913/A U2913/VDD! U2913/GND!  INVERT_I
V7 U2913/VDD! 0 1.1
V8 U2913/GND! 0 0

*Net victim vic(n_403)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2790/Z 0.0001
R2 vic U3055/B 0.0001
R3 vic U2913/A 0.0001
R4 vic U2820/B 0.0001

*Net connected to side receiver's o/p rcv1(n_255)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3055/Z 0.0001
R6 rcv1 U2876/B 0.0001
C1 U2876/B 0 2.636e-15

*Net connected to side receiver's o/p rcv2(n_188)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv2 U2913/Z 0.0001
R8 rcv2 U2947/A 0.0001
C2 U2947/A 0 2.711e-15
.ENDS

.SUBCKT Stage9 U2820/B U2820/Z U2922/A

*driver Inst(U2820)
XU2820 U2820/Z U2820/A U2820/B U2820/VDD! U2820/GND!  NOR2_A
V1 U2820/VDD! 0 1.1
V2 U2820/GND! 0 0
V3 U2820/A 0 0

*side receiver Inst(U3053)
XU3053 U3053/Z U3053/A U3053/B U3053/VDD! U3053/GND!  NAND2_A
V4 U3053/VDD! 0 1.1
V5 U3053/GND! 0 0
V6 U3053/B 0 1.1

*Net victim vic(n_341)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2820/Z 0.0001
R2 vic U3053/A 0.0001
R3 vic U2922/A 0.0001

*Net connected to side receiver's o/p rcv1(n_254)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv1 U3053/Z 0.0001
R5 rcv1 U2877/B 0.0001
C1 U2877/B 0 2.636e-15
.ENDS

.SUBCKT Stage10 U2922/A U2922/Z U2792/B

*driver Inst(U2922)
XU2922 U2922/Z U2922/A U2922/VDD! U2922/GND!  INVERT_I
V1 U2922/VDD! 0 1.1
V2 U2922/GND! 0 0

*side receiver Inst(U2817)
XU2817 U2817/Z U2817/A U2817/B U2817/VDD! U2817/GND!  NAND2_A
V3 U2817/VDD! 0 1.1
V4 U2817/GND! 0 0
V5 U2817/B 0 1.1

*Net victim vic(n_395)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2922/Z 0.0001
R2 vic U2817/A 0.0001
R3 vic U2792/B 0.0001

*Net connected to side receiver's o/p rcv1(n_346)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv1 U2817/Z 0.0001
R5 rcv1 U3108/A 0.0001
R6 rcv1 U3107/B 0.0001
R7 rcv1 U3050/B 0.0001
C1 U3108/A 0 2.711e-15
C2 U3107/B 0 2.431e-15
C3 U3050/B 0 2.738e-15
.ENDS

.SUBCKT Stage11 U2792/B U2792/Z U2951/A

*driver Inst(U2792)
XU2792 U2792/Z U2792/A U2792/B U2792/VDD! U2792/GND!  AND2_B
V1 U2792/VDD! 0 1.1
V2 U2792/GND! 0 0
V3 U2792/A 0 1.1

*side receiver Inst(U3020)
XU3020 U3020/Z U3020/A U3020/B U3020/VDD! U3020/GND!  NAND2_A
V4 U3020/VDD! 0 1.1
V5 U3020/GND! 0 0
V6 U3020/A 0 1.1

*side receiver Inst(U2914)
XU2914 U2914/Z U2914/A U2914/VDD! U2914/GND!  INVERT_I
V7 U2914/VDD! 0 1.1
V8 U2914/GND! 0 0

*Net victim vic(n_397)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2792/Z 0.0001
R2 vic U3020/B 0.0001
R3 vic U2951/A 0.0001
R4 vic U2914/A 0.0001

*Net connected to side receiver's o/p rcv1(n_132)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3020/Z 0.0001
R6 rcv1 U3021/B 0.0001
C1 U3021/B 0 2.431e-15

*Net connected to side receiver's o/p rcv3(n_187)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv3 U2914/Z 0.0001
R8 rcv3 U3025/B 0.0001
R9 rcv3 U2953/A 0.0001
C2 U3025/B 0 2.431e-15
C3 U2953/A 0 2.711e-15
.ENDS

.SUBCKT Stage12 U2951/A U2951/Z U2952/A

*driver Inst(U2951)
XU2951 U2951/Z U2951/A U2951/B U2951/VDD! U2951/GND!  OR2_B
V1 U2951/VDD! 0 1.1
V2 U2951/GND! 0 0
V3 U2951/B 0 0

*Net victim vic(n_169)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2951/Z 0.0001
R2 vic U2952/A 0.0001
.ENDS

.SUBCKT Stage13 U2952/A U2952/Z U2795/B

*driver Inst(U2952)
XU2952 U2952/Z U2952/A U2952/B U2952/VDD! U2952/GND!  NAND2_A
V1 U2952/VDD! 0 1.1
V2 U2952/GND! 0 0
V3 U2952/B 0 1.1

*Net victim vic(n_388)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2952/Z 0.0001
R2 vic U2795/B 0.0001
.ENDS

.SUBCKT Stage14 U2795/B U2795/Z U2955/B

*driver Inst(U2795)
XU2795 U2795/Z U2795/A U2795/B U2795/VDD! U2795/GND!  AND2_B
V1 U2795/VDD! 0 1.1
V2 U2795/GND! 0 0
V3 U2795/A 0 1.1

*side receiver Inst(U3035)
XU3035 U3035/Z U3035/A U3035/B U3035/VDD! U3035/GND!  NAND2_A
V4 U3035/VDD! 0 1.1
V5 U3035/GND! 0 0
V6 U3035/A 0 1.1

*side receiver Inst(U2954)
XU2954 U2954/Z U2954/A U2954/VDD! U2954/GND!  INVERT_I
V7 U2954/VDD! 0 1.1
V8 U2954/GND! 0 0

*Net victim vic(n_390)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2795/Z 0.0001
R2 vic U3035/B 0.0001
R3 vic U2955/B 0.0001
R4 vic U2954/A 0.0001

*Net connected to side receiver's o/p rcv1(n_274)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3035/Z 0.0001
R6 rcv1 U2867/B 0.0001
C1 U2867/B 0 2.636e-15

*Net connected to side receiver's o/p rcv3(n_168)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv3 U2954/Z 0.0001
R8 rcv3 U3030/B 0.0001
R9 rcv3 U2957/A 0.0001
C2 U3030/B 0 2.431e-15
C3 U2957/A 0 2.711e-15
.ENDS

.SUBCKT Stage15 U2955/B U2955/Z U2956/B

*driver Inst(U2955)
XU2955 U2955/Z U2955/A U2955/B U2955/VDD! U2955/GND!  OR2_B
V1 U2955/VDD! 0 1.1
V2 U2955/GND! 0 0
V3 U2955/A 0 0

*Net victim vic(n_167)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2955/Z 0.0001
R2 vic U2956/B 0.0001
.ENDS

.SUBCKT Stage16 U2956/B U2956/Z U2798/B

*driver Inst(U2956)
XU2956 U2956/Z U2956/A U2956/B U2956/VDD! U2956/GND!  NAND2_A
V1 U2956/VDD! 0 1.1
V2 U2956/GND! 0 0
V3 U2956/A 0 1.1

*Net victim vic(n_381)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2956/Z 0.0001
R2 vic U2798/B 0.0001
.ENDS

.SUBCKT Stage17 U2798/B U2798/Z U2959/B

*driver Inst(U2798)
XU2798 U2798/Z U2798/A U2798/B U2798/VDD! U2798/GND!  AND2_B
V1 U2798/VDD! 0 1.1
V2 U2798/GND! 0 0
V3 U2798/A 0 1.1

*side receiver Inst(U3040)
XU3040 U3040/Z U3040/A U3040/B U3040/VDD! U3040/GND!  NAND2_A
V4 U3040/VDD! 0 1.1
V5 U3040/GND! 0 0
V6 U3040/A 0 1.1

*side receiver Inst(U2958)
XU2958 U2958/Z U2958/A U2958/VDD! U2958/GND!  INVERT_I
V7 U2958/VDD! 0 1.1
V8 U2958/GND! 0 0

*Net victim vic(n_383)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2798/Z 0.0001
R2 vic U3040/B 0.0001
R3 vic U2959/B 0.0001
R4 vic U2958/A 0.0001

*Net connected to side receiver's o/p rcv1(n_120)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3040/Z 0.0001
R6 rcv1 U3041/B 0.0001
C1 U3041/B 0 2.431e-15

*Net connected to side receiver's o/p rcv3(n_166)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv3 U2958/Z 0.0001
R8 rcv3 U3045/B 0.0001
R9 rcv3 U2961/A 0.0001
C2 U3045/B 0 2.431e-15
C3 U2961/A 0 2.711e-15
.ENDS

.SUBCKT Stage18 U2959/B U2959/Z U2960/B

*driver Inst(U2959)
XU2959 U2959/Z U2959/A U2959/B U2959/VDD! U2959/GND!  OR2_B
V1 U2959/VDD! 0 1.1
V2 U2959/GND! 0 0
V3 U2959/A 0 0

*Net victim vic(n_165)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2959/Z 0.0001
R2 vic U2960/B 0.0001
.ENDS

.SUBCKT Stage19 U2960/B U2960/Z U2801/B

*driver Inst(U2960)
XU2960 U2960/Z U2960/A U2960/B U2960/VDD! U2960/GND!  NAND2_A
V1 U2960/VDD! 0 1.1
V2 U2960/GND! 0 0
V3 U2960/A 0 1.1

*Net victim vic(n_374)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2960/Z 0.0001
R2 vic U2801/B 0.0001
.ENDS

.SUBCKT Stage20 U2801/B U2801/Z U2963/B

*driver Inst(U2801)
XU2801 U2801/Z U2801/A U2801/B U2801/VDD! U2801/GND!  AND2_B
V1 U2801/VDD! 0 1.1
V2 U2801/GND! 0 0
V3 U2801/A 0 1.1

*side receiver Inst(U3013)
XU3013 U3013/Z U3013/A U3013/B U3013/VDD! U3013/GND!  NAND2_A
V4 U3013/VDD! 0 1.1
V5 U3013/GND! 0 0
V6 U3013/A 0 1.1

*side receiver Inst(U2962)
XU2962 U2962/Z U2962/A U2962/VDD! U2962/GND!  INVERT_I
V7 U2962/VDD! 0 1.1
V8 U2962/GND! 0 0

*Net victim vic(n_376)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2801/Z 0.0001
R2 vic U3013/B 0.0001
R3 vic U2963/B 0.0001
R4 vic U2962/A 0.0001

*Net connected to side receiver's o/p rcv1(n_288)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3013/Z 0.0001
R6 rcv1 U2860/B 0.0001
C1 U2860/B 0 2.636e-15

*Net connected to side receiver's o/p rcv3(n_164)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv3 U2962/Z 0.0001
R8 rcv3 U3008/B 0.0001
R9 rcv3 U2965/A 0.0001
C2 U3008/B 0 2.431e-15
C3 U2965/A 0 2.711e-15
.ENDS

.SUBCKT Stage21 U2963/B U2963/Z U2964/B

*driver Inst(U2963)
XU2963 U2963/Z U2963/A U2963/B U2963/VDD! U2963/GND!  OR2_B
V1 U2963/VDD! 0 1.1
V2 U2963/GND! 0 0
V3 U2963/A 0 0

*Net victim vic(n_163)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2963/Z 0.0001
R2 vic U2964/B 0.0001
.ENDS

.SUBCKT Stage22 U2964/B U2964/Z U2805/B

*driver Inst(U2964)
XU2964 U2964/Z U2964/A U2964/B U2964/VDD! U2964/GND!  NAND2_A
V1 U2964/VDD! 0 1.1
V2 U2964/GND! 0 0
V3 U2964/A 0 1.1

*Net victim vic(n_366)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2964/Z 0.0001
R2 vic U2805/B 0.0001
.ENDS

.SUBCKT Stage23 U2805/B U2805/Z U2966/A

*driver Inst(U2805)
XU2805 U2805/Z U2805/A U2805/B U2805/VDD! U2805/GND!  AND2_B
V1 U2805/VDD! 0 1.1
V2 U2805/GND! 0 0
V3 U2805/A 0 1.1

*side receiver Inst(U2981)
XU2981 U2981/Z U2981/A U2981/B U2981/VDD! U2981/GND!  OR2_B
V4 U2981/VDD! 0 1.1
V5 U2981/GND! 0 0
V6 U2981/B 0 0

*side receiver Inst(U2967)
XU2967 U2967/Z U2967/A U2967/B U2967/VDD! U2967/GND!  NAND2_A
V7 U2967/VDD! 0 1.1
V8 U2967/GND! 0 0
V9 U2967/B 0 1.1

*Net victim vic(n_368)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2805/Z 0.0001
R2 vic U2981/A 0.0001
R3 vic U2967/A 0.0001
R4 vic U2966/A 0.0001

*Net connected to side receiver's o/p rcv1(n_357)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U2981/Z 0.0001
R6 rcv1 U2811/A 0.0001
C1 U2811/A 0 2.597e-15

*Net connected to side receiver's o/p rcv2(n_161)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv2 U2967/Z 0.0001
R8 rcv2 U2968/B 0.0001
C2 U2968/B 0 2.431e-15
.ENDS

.SUBCKT Stage24 U2966/A U2966/Z U2979/A

*driver Inst(U2966)
XU2966 U2966/Z U2966/A U2966/VDD! U2966/GND!  INVERT_I
V1 U2966/VDD! 0 1.1
V2 U2966/GND! 0 0

*side receiver Inst(U2972)
XU2972 U2972/Z U2972/A U2972/B U2972/VDD! U2972/GND!  NAND2_A
V3 U2972/VDD! 0 1.1
V4 U2972/GND! 0 0
V5 U2972/A 0 1.1

*Net victim vic(n_162)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2966/Z 0.0001
R2 vic U2979/A 0.0001
R3 vic U2972/B 0.0001

*Net connected to side receiver's o/p rcv2(n_312)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv2 U2972/Z 0.0001
R5 rcv2 U2847/B 0.0001
C1 U2847/B 0 2.636e-15
.ENDS

.SUBCKT Stage25 U2979/A U2979/Z U2980/B

*driver Inst(U2979)
XU2979 U2979/Z U2979/A U2979/B U2979/VDD! U2979/GND!  OR2_B
V1 U2979/VDD! 0 1.1
V2 U2979/GND! 0 0
V3 U2979/B 0 0

*Net victim vic(n_155)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2979/Z 0.0001
R2 vic U2980/B 0.0001
.ENDS

.SUBCKT Stage26 U2980/B U2980/Z U2811/B

*driver Inst(U2980)
XU2980 U2980/Z U2980/A U2980/B U2980/VDD! U2980/GND!  NAND2_A
V1 U2980/VDD! 0 1.1
V2 U2980/GND! 0 0
V3 U2980/A 0 1.1

*Net victim vic(n_356)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2980/Z 0.0001
R2 vic U2811/B 0.0001
.ENDS

.SUBCKT Stage27 U2811/B U2811/Z U2995/B

*driver Inst(U2811)
XU2811 U2811/Z U2811/A U2811/B U2811/VDD! U2811/GND!  AND2_B
V1 U2811/VDD! 0 1.1
V2 U2811/GND! 0 0
V3 U2811/A 0 1.1

*side receiver Inst(U2983)
XU2983 U2983/Z U2983/A U2983/B U2983/VDD! U2983/GND!  NAND2_A
V4 U2983/VDD! 0 1.1
V5 U2983/GND! 0 0
V6 U2983/B 0 1.1

*side receiver Inst(U2982)
XU2982 U2982/Z U2982/A U2982/VDD! U2982/GND!  INVERT_I
V7 U2982/VDD! 0 1.1
V8 U2982/GND! 0 0

*Net victim vic(n_358)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2811/Z 0.0001
R2 vic U2995/B 0.0001
R3 vic U2983/A 0.0001
R4 vic U2982/A 0.0001

*Net connected to side receiver's o/p rcv2(n_153)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv2 U2983/Z 0.0001
R6 rcv2 U2984/B 0.0001
C1 U2984/B 0 2.431e-15

*Net connected to side receiver's o/p rcv3(n_154)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv3 U2982/Z 0.0001
R8 rcv3 U2997/A 0.0001
R9 rcv3 U2988/B 0.0001
C2 U2997/A 0 2.711e-15
C3 U2988/B 0 2.431e-15
.ENDS

.SUBCKT Stage28 U2995/B U2995/Z U2996/A

*driver Inst(U2995)
XU2995 U2995/Z U2995/A U2995/B U2995/VDD! U2995/GND!  OR2_B
V1 U2995/VDD! 0 1.1
V2 U2995/GND! 0 0
V3 U2995/A 0 0

*Net victim vic(n_147)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2995/Z 0.0001
R2 vic U2996/A 0.0001
.ENDS

.SUBCKT Stage29 U2996/A U2996/Z U2815/B

*driver Inst(U2996)
XU2996 U2996/Z U2996/A U2996/B U2996/VDD! U2996/GND!  NAND2_A
V1 U2996/VDD! 0 1.1
V2 U2996/GND! 0 0
V3 U2996/B 0 1.1

*Net victim vic(n_348)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2996/Z 0.0001
R2 vic U2815/B 0.0001
.ENDS

.SUBCKT Stage30 U2815/B U2815/Z U2998/A

*driver Inst(U2815)
XU2815 U2815/Z U2815/A U2815/B U2815/VDD! U2815/GND!  AND2_B
V1 U2815/VDD! 0 1.1
V2 U2815/GND! 0 0
V3 U2815/A 0 1.1

*side receiver Inst(U3017)
XU3017 U3017/Z U3017/A U3017/B U3017/VDD! U3017/GND!  OR2_B
V4 U3017/VDD! 0 1.1
V5 U3017/GND! 0 0
V6 U3017/A 0 0

*side receiver Inst(U3004)
XU3004 U3004/Z U3004/A U3004/B U3004/VDD! U3004/GND!  NAND2_A
V7 U3004/VDD! 0 1.1
V8 U3004/GND! 0 0
V9 U3004/A 0 1.1

*Net victim vic(n_350)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2815/Z 0.0001
R2 vic U3017/B 0.0001
R3 vic U3004/B 0.0001
R4 vic U2998/A 0.0001

*Net connected to side receiver's o/p rcv1(n_133)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R5 rcv1 U3017/Z 0.0001
R6 rcv1 U3018/B 0.0001
C1 U3018/B 0 2.431e-15

*Net connected to side receiver's o/p rcv2(n_294)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R7 rcv2 U3004/Z 0.0001
R8 rcv2 U2857/B 0.0001
C2 U2857/B 0 2.636e-15
.ENDS

.SUBCKT Stage31 U2998/A U2998/Z U2999/B

*driver Inst(U2998)
XU2998 U2998/Z U2998/A U2998/VDD! U2998/GND!  INVERT_I
V1 U2998/VDD! 0 1.1
V2 U2998/GND! 0 0

*side receiver Inst(U3019)
XU3019 U3019/Z U3019/A U3019/B U3019/VDD! U3019/GND!  OR2_B
V3 U3019/VDD! 0 1.1
V4 U3019/GND! 0 0
V5 U3019/B 0 0

*Net victim vic(n_146)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2998/Z 0.0001
R2 vic U3019/A 0.0001
R3 vic U2999/B 0.0001

*Net connected to side receiver's o/p rcv1(n_431)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv1 U3019/Z 0.0001
R5 rcv1 U2767/A 0.0001
C1 U2767/A 0 2.295e-15
.ENDS

.SUBCKT Stage32 U2999/B U2999/Z U3000/B

*driver Inst(U2999)
XU2999 U2999/Z U2999/A U2999/B U2999/VDD! U2999/GND!  NAND2_A
V1 U2999/VDD! 0 1.1
V2 U2999/GND! 0 0
V3 U2999/A 0 1.1

*Net victim vic(n_145)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2999/Z 0.0001
R2 vic U3000/B 0.0001
.ENDS

.SUBCKT Stage33 U3000/B U3000/Z U3086/B

*driver Inst(U3000)
XU3000 U3000/Z U3000/A U3000/B U3000/VDD! U3000/GND!  NAND2_A
V1 U3000/VDD! 0 1.1
V2 U3000/GND! 0 0
V3 U3000/A 0 1.1

*side receiver Inst(U3002)
XU3002 U3002/Z U3002/A U3002/B U3002/VDD! U3002/GND!  NAND2_A
V4 U3002/VDD! 0 1.1
V5 U3002/GND! 0 0
V6 U3002/B 0 1.1

*Net victim vic(n_144)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U3000/Z 0.0001
R2 vic U3086/B 0.0001
R3 vic U3002/A 0.0001

*Net connected to side receiver's o/p rcv2(n_141)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R4 rcv2 U3002/Z 0.0001
R5 rcv2 U3003/B 0.0001
C1 U3003/B 0 2.431e-15
.ENDS

.SUBCKT Stage34 U3086/B U3086/Z U3001/B

*driver Inst(U3086)
XU3086 U3086/Z U3086/A U3086/B U3086/VDD! U3086/GND!  NAND2_A
V1 U3086/VDD! 0 1.1
V2 U3086/GND! 0 0
V3 U3086/A 0 1.1

*Net victim vic(n_142)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U3086/Z 0.0001
R2 vic U3001/B 0.0001
.ENDS

.SUBCKT Stage35 U3001/B U3001/Z U3006/B

*driver Inst(U3001)
XU3001 U3001/Z U3001/A U3001/B U3001/VDD! U3001/GND!  NAND2_A
V1 U3001/VDD! 0 1.1
V2 U3001/GND! 0 0
V3 U3001/A 0 1.1

*Net victim vic(n_143)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U3001/Z 0.0001
R2 vic U3006/B 0.0001
.ENDS

.SUBCKT Stage36 U3006/B U3006/Z U2858/B

*driver Inst(U3006)
XU3006 U3006/Z U3006/A U3006/B U3006/VDD! U3006/GND!  NAND2_A
V1 U3006/VDD! 0 1.1
V2 U3006/GND! 0 0
V3 U3006/A 0 1.1

*Net victim vic(n_292)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U3006/Z 0.0001
R2 vic U2858/B 0.0001
.ENDS

.SUBCKT Stage37 U2858/B U2858/Z U2764/A

*driver Inst(U2858)
XU2858 U2858/Z U2858/A U2858/B U2858/VDD! U2858/GND!  AND2_B
V1 U2858/VDD! 0 1.1
V2 U2858/GND! 0 0
V3 U2858/A 0 1.1

*Net victim vic(n_437)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2858/Z 0.0001
R2 vic U2764/A 0.0001
.ENDS

.SUBCKT Stage38 U2764/A U2764/Z X_878gat

*driver Inst(U2764)
XU2764 U2764/Z U2764/A U2764/B U2764/VDD! U2764/GND!  NAND2_A
V1 U2764/VDD! 0 1.1
V2 U2764/GND! 0 0
V3 U2764/B 0 1.1

*Net victim vic(X_878gat)
*Parasitics not found for this net, creating dummy net with 0 value resistor
R1 vic U2764/Z 0.0001
R2 vic X_878gat 0.0001
C1 X_878gat 0 1e-17
.ENDS

*---------------------

.END
