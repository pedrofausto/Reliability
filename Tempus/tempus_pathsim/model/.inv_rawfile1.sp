*****************************************************************************
*
*  Cadence (R) Virtuoso (R) RelXpert (R) Reliability Simulator
*  Version 12.1.1.330.isr21 64bit 04/17/2014 02:02 (csvcm16c-1)
*  Copyright(C) 2001-2014 Cadence Design Systems, Inc. All rights reserved worldwide.
*  Cadence, Virtuoso and RelXpert are registered trademarks of Cadence Design Systems, Inc.
*  All others are the property of their respective holders.
*
*  USER: pedrofausto	HOST: sala1206m04.eee.eng.ufmg.br	HOSTID: FFFFFFFFA4962C21	PID: 13328
*  Memory: available: 6.1432 GB 	physical: 16.6011 GB
*  CPU(1 of 8): CPU0 Intel(R) Xeon(R) CPU E5-1620 v2 @ 3.70GHz 2116.226MHz
*
*  Netlist file: inv
*  Starting time: Wed Sep 23 13:34:40 2015
*
*  Command Line Input: /usr/local/Cadence/MMSIM/tools/relxpert/bin/64bit/prebert -sp inv inv.p1
*
*****************************************************************************

simulator lang = spice
